options:
  parameters:
    author: Christopher O'Reilly
    comment: This is a basic AM radio with C-QUAM reception and notch filtering
    copyright: Tropical Radio Network
    description: AM Radio with C-QUAM reception
    generate_options: qt_gui
    id: AMradio
    output_language: python
    title: AM Stereo radio
  states: {}

blocks:
- name: Stereo_Lock
  id: variable_function_probe
  parameters:
    block_id: epy_block_5
    function_name: get_lock_status
    poll_rate: '10'
    value: '0'
  states: {}
- name: audio_bw
  id: variable_qtgui_range
  parameters:
    label: Audio bandwidth
    start: '2500'
    step: '1'
    stop: '15000'
    value: '10000'
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    lbl: Frequency
    maxFreqHz: 30000e3
    minFreqHz: 500e3
    value: 7390e3
  states: {}
- name: mono_mode
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    label: STEREO MODE
    'true': '0'
    type: int
    value: '0'
  states: {}
- name: notch_freq_v
  id: variable_qtgui_range
  parameters:
    label: Variable notch
    rangeType: int
    start: '2000'
    step: '1'
    stop: '15000'
    value: '5000'
  states: {}
- name: notch_mode
  id: variable_qtgui_chooser
  parameters:
    label: Notch filter
    label0: 5KHz (SW)
    label1: 9KHz (Global)
    label2: 10KHz (USA)
    label3: Variable
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '2'
    widget: radio_buttons
  states: {}
- name: pilot_val
  id: variable_function_probe
  parameters:
    block_id: epy_block_5
    function_name: get_pilot_status
    poll_rate: '10'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1000e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import math
      from scipy import signal  # <--- THIS FIXES THE "NOT DEFINED" ERROR

      class cquam_decoder(gr.sync_block):
          def __init__(self, sample_rate=120000, notch_freq=9000, notch_q=30.0, mono_mode=False):
              gr.sync_block.__init__(self,
                  name="C-QUAM Field Decoder",
                  in_sig=[np.complex64],
                  out_sig=[np.float32, np.float32]
              )
              self.fs = float(sample_rate)
              self.notch_freq = notch_freq
              self.notch_q = notch_q
              self.mono_mode = mono_mode
              
              # PLL & Correction
              self.zeta = 0.707 
              self.omegaN = 100.0
              self._update_gains()

              # States
              self.phz, self.omega2, self.cos_gamma = 0.0, 0.0, 1.0
              
              # Initialize filter states (zi) to prevent clicks
              self.b, self.a = signal.iirnotch(self.notch_freq, self.notch_q, self.fs)
              self.zi_l = signal.lfilter_zi(self.b, self.a) * 0
              self.zi_r = signal.lfilter_zi(self.b, self.a) * 0
              
              # Monitor States
              self.lock_level = 0.0
              self.pilot_mag = 0.0

          def _update_gains(self):
              T = 1.0 / self.fs
              self.alpha = (2.0 * self.zeta * self.omegaN * T) / (1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2)
              self.beta = ((self.omegaN * T)**2) / (1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2)
              
              ############################################################################################################
              #The code of interest below, I have entered in both of the GUI blocks where the ID field contains notch_freq, 
              #I enabled one and disabled the other to test each, 
              #neither the select or the slider works, 
              #still is stuck on the default setting, I can change the default to 5KHz on the shortwave station, then it works,
              #Same thing if I tune into an AM broadcast station when the default is at 5KHz, theres the whistle,
              #vary or select 9KHz, whistle is still there, close program, fill default with 9KHz, then it works
              #########################################################################################################

          def _update_notch_coeffs(self):
              """Calculates coefficients only when a control changes."""
              self.b, self.a = signal.iirnotch(self.notch_freq, self.notch_q, self.fs) #this matches up exactly so I have not changed it

          # Callbacks for GRC
          #def set_notch_freq(self, notch_freq):          #(self, freq): 
              ##self.notch_freq = freq #this is the previous that has been replaces with the line below
              #self.notch_freq = notch_freq #this is the replacement under suggestion
              #self._update_notch_coeffs()
              
          def set_notch_freq(self, notch_freq):
              print(f"DEBUG: Notch updating to {notch_freq} Hz") # <--- ADD THIS
              #print(notch_freq)
              self.notch_freq = notch_freq
              self._update_notch_coeffs()


          def set_notch_q(self, notch_q):         #(self, q):
              #self.notch_q = q   #this is the previous that has been replaces with the line below
              self.notch_q = notch_q #this is the replacement under suggestion
              self._update_notch_coeffs()
              
              ############################
              #End of the code of interest
              ############################
              
              

          def set_mono_mode(self, mode): self.mono_mode = bool(mode)

          def work(self, input_items, output_items):
              inp, L, R = input_items[0], output_items[0], output_items[1]
              n = len(inp)
              
              # Temporary arrays to hold raw audio before the notch
              raw_l = np.zeros(n, dtype=np.float32)
              raw_r = np.zeros(n, dtype=np.float32)
              
              # Fast local copies
              phz, omega2, cos_gamma = self.phz, self.omega2, self.cos_gamma
              
              # 1. THE DEMODULATION LOOP (Keep your original logic)
              for i in range(n):
                  vco = math.cos(phz) - 1j * math.sin(phz)
                  bb = inp[i] * vco
                  I, Q = bb.real, bb.imag
                  env = math.sqrt(I*I + Q*Q) + 1e-9
                  
                  # PLL
                  det = Q / env 
                  omega2 += self.beta * det
                  phz = (phz + self.alpha * det + omega2) % (2.0 * math.pi)

                  # C-QUAM Logic
                  cos_gamma += 0.005 * ((I / env) - cos_gamma)
                  LpR = (env * cos_gamma) - 1.0
                  LmR = Q / cos_gamma

                  raw_l[i], raw_r[i] = 0.5*(LpR + LmR), 0.5*(LpR - LmR)

              # Update persistent states
              self.phz, self.omega2, self.cos_gamma = phz, omega2, cos_gamma

              # 2. EFFICIENT NOTCH FILTERING (Run once per block, outside the loop)
              L[:], self.zi_l = signal.lfilter(self.b, self.a, raw_l, zi=self.zi_l)
              R[:], self.zi_r = signal.lfilter(self.b, self.a, raw_r, zi=self.zi_r)

              # Mono mode check
              if self.mono_mode:
                  m = 0.5 * (L + R)
                  L[:], R[:] = m, m

              return n
    mono_mode: mono_mode
    notch_freq: notch_freq
    notch_q: '20'
    sample_rate: '120000'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class notch_frequency_controller(gr.basic_block):
          def __init__(self, notch_mode=3, notch_freq_v=5000):
              gr.basic_block.__init__(self,
                  name="Notch Frequency Controller",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern("notch_freq"))
              self.notch_mode = notch_mode
              self.notch_freq_v = notch_freq_v
              self.last_freq = None
              self.freq_map = {0: 5000, 1: 9000, 2: 10000, 3: notch_freq_v}
              self._publish_freq()
              
          def set_notch_mode(self, mode):
              self.notch_mode = int(mode)
              print(f"Mode: {self.notch_mode}")
              self._publish_freq()
              
          def set_notch_freq_v(self, freq):
              self.notch_freq_v = int(freq)
              if self.notch_mode == 3:
                  self._publish_freq()
              
          def _publish_freq(self):
              if self.notch_mode in self.freq_map:
                  freq = self.freq_map[self.notch_mode]
                  if self.notch_mode == 3:
                      freq = self.notch_freq_v
              else:
                  freq = self.notch_freq_v
              
              if freq != self.last_freq:
                  self.last_freq = freq
                  print(f"Publishing: {freq} Hz")
                  self.message_port_pub(pmt.intern("notch_freq"), pmt.from_long(int(freq)))
                  
          def work(self, input_items, output_items):
              return -1
    notch_freq_v: notch_freq_v
    notch_mode: notch_mode
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math
      import pmt
      from scipy import signal

      class cquam_decoder(gr.sync_block):
          def __init__(self, sample_rate=120000, notch_freq=9000, notch_q=30.0, mono_mode=False):
              gr.sync_block.__init__(self,
                  name="C-QUAM Field Decoder",
                  in_sig=[np.complex64],
                  out_sig=[np.float32, np.float32]
              )
              self.fs = float(sample_rate)
              self.notch_freq = notch_freq
              self.notch_q = notch_q
              self.mono_mode = mono_mode
              
              
              # PLL & States
              self.zeta, self.omegaN = 0.707, 100.0
              self._update_gains()
              self.phz, self.omega2, self.cos_gamma = 0.0, 0.0, 1.0
              self.lock_level, self.pilot_mag = 0.0, 0.0
              
              # Initialize filter coefficients and states
              self._update_notch_coeffs()
              self.zi_l = signal.lfilter_zi(self.b, self.a) * 0
              self.zi_r = signal.lfilter_zi(self.b, self.a) * 0
              
              # Register message port for notch frequency updates
              self.message_port_register_in(pmt.intern("notch_freq"))
              self.set_msg_handler(pmt.intern("notch_freq"), self.handle_notch_freq)

          def _update_gains(self):
              T = 1.0 / self.fs
              denom = 1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2
              self.alpha = (2.0 * self.zeta * self.omegaN * T) / denom
              self.beta = ((self.omegaN * T)**2) / denom

          def _update_notch_coeffs(self):
              # Optimized Scipy notch
              self.b, self.a = signal.iirnotch(self.notch_freq, self.notch_q, self.fs)

          def set_notch_freq(self, notch_freq):
              if self.notch_freq != notch_freq:
                  self.notch_freq = notch_freq
                  print(f"DEBUG: Notch frequency updated to {self.notch_freq} Hz")
                  self._update_notch_coeffs()

          def set_notch_q(self, notch_q):
              if self.notch_q != notch_q:
                  self.notch_q = notch_q
                  self._update_notch_coeffs()

          def set_mono_mode(self, mode):
              self.mono_mode = bool(mode)

          def handle_notch_freq(self, msg):
              """Handle notch frequency changes from GUI variable"""
              try:
                  if isinstance(msg, pmt.pmt_object):
                      freq_val = pmt.to_float(msg)
                  else:
                      freq_val = float(msg)
                  
                  if self.notch_freq != freq_val:
                      self.notch_freq = freq_val
                      print(f"DEBUG: Notch frequency message received: {self.notch_freq} Hz")
                      self._update_notch_coeffs()
              except Exception as e:
                  print(f"Error handling notch_freq message: {e}")

          def get_lock_status(self):
              return self.lock_level

          def get_pilot_status(self):
              return 1.0 if self.pilot_mag > 0.015 else 0.0

          def work(self, input_items, output_items):
              inp = input_items[0]
              L_out = output_items[0]
              R_out = output_items[1]
              n = len(inp)

              # Buffers to hold raw demodulated audio for vector filtering
              raw_l = np.zeros(n, dtype=np.float32)
              raw_r = np.zeros(n, dtype=np.float32)
              
              phz, omega2, cos_gamma = self.phz, self.omega2, self.cos_gamma
              
              # 1. PER-SAMPLE DEMODULATION & MONITORING
              for i in range(n):
                  vco = math.cos(phz) - 1j * math.sin(phz)
                  bb = inp[i] * vco
                  I, Q = bb.real, bb.imag
                  env = math.sqrt(I*I + Q*Q) + 1e-9
                  
                  # PLL
                  det = Q / env 
                  omega2 += self.beta * det
                  phz = (phz + self.alpha * det + omega2) % (2.0 * math.pi)

                  # C-QUAM Logic
                  cos_gamma += 0.005 * ((I / env) - cos_gamma)
                  LpR = (env * cos_gamma) - 1.0
                  LmR = Q / cos_gamma

                  # Monitor Logic (Lock & 25Hz Pilot)
                  self.lock_level += 0.001 * (max(0, I/env) - self.lock_level)
                  self.pilot_mag += 0.0002 * (abs(LmR) - self.pilot_mag)

                  raw_l[i], raw_r[i] = 0.5*(LpR + LmR), 0.5*(LpR - LmR)

              self.phz, self.omega2, self.cos_gamma = phz, omega2, cos_gamma

              # 2. VECTORIZED NOTCH FILTERING (OUTSIDE THE LOOP)
              L_out[:], self.zi_l = signal.lfilter(self.b, self.a, raw_l, zi=self.zi_l)
              R_out[:], self.zi_r = signal.lfilter(self.b, self.a, raw_r, zi=self.zi_r)

              if self.mono_mode:
                  m = 0.5 * (L_out + R_out)
                  L_out[:], R_out[:] = m, m

              return n
    mono_mode: mono_mode
    notch_freq: '9000'
    notch_q: '30'
    sample_rate: '120000'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-100e3'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {}
- name: lock_val
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    label: Carrier Lock
    state: True if Stereo_Lock > 0.7 else False
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_bw
    gain: '3'
    interp: '1'
    maxoutbuf: '16'
    minoutbuf: '4'
    samp_rate: '120000'
    type: interp_fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: pilot_led
  id: qtgui_ledindicator
  parameters:
    cellalignment: '3'
    label: Stereo Pilot
    offColor: black
    onColor: blue
    state: True if pilot_val > 0.5 else False
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000'
    interp: '120'
    maxoutbuf: '16'
    minoutbuf: '4'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '120'
    interp: '48'
    maxoutbuf: '16'
    minoutbuf: '4'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '120'
    interp: '48'
    maxoutbuf: '16'
    minoutbuf: '4'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0,direct_samp=2
    bb_gain0: '1'
    bw0: '15000'
    freq0: freq+100000
    gain0: '0'
    gain_mode0: 'True'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-4'
    reference: '0.2'
  states: {}

connections:
- [epy_block_0, '0', rational_resampler_xxx_0_0_0_0_0, '0']
- [epy_block_0, '1', rational_resampler_xxx_0_0_0_0, '0']
- [epy_block_1, notch_freq, epy_block_5, notch_freq]
- [epy_block_5, '0', rational_resampler_xxx_0_0_0_0, '0']
- [epy_block_5, '1', rational_resampler_xxx_0_0_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']
- [low_pass_filter_0, '0', epy_block_5, '0']
- [rational_resampler_xxx_0_0_0, '0', satellites_rms_agc_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0_0_0_0, '0', audio_sink_0, '1']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [satellites_rms_agc_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
