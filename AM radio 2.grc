options:
  parameters:
    author: Christopher O'Reilly
    comment: This is a basic AM radio with C-QUAM reception and notch filtering
    copyright: Tropical Radio Network
    description: AM Radio with C-QUAM reception
    generate_options: qt_gui
    id: AMradio
    output_language: python
    title: AM Stereo radio
  states: {}

blocks:
- name: Stereo_Lock
  id: variable_function_probe
  parameters:
    block_id: epy_block_5
    function_name: get_lock_status
    poll_rate: '10'
    value: '0'
  states: {}
- name: audio_bw
  id: variable_qtgui_range
  parameters:
    label: Audio bandwidth
    start: '2500'
    step: '1'
    stop: '15000'
    value: '10000'
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    lbl: Frequency
    maxFreqHz: 30000e3
    minFreqHz: 500e3
    value: 846e3
  states: {}
- name: mono_mode
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    label: STEREO MODE
    'true': '0'
    type: int
    value: '0'
  states: {}
- name: notch_freq
  id: variable_qtgui_chooser
  parameters:
    label: Notch_freq
    label0: SW BC 5KHz
    label1: AM BC 9KHz
    label2: AM BC USA 10KHz
    label3: Variable
    labels: '["5K SWBC", "9 AMBC", "10K AMBC USA"]'
    num_opts: '4'
    option0: '5000'
    option1: '9000'
    option2: '10000'
    option3: notch_freq_v
    options: '[5000, 9000, 10000]'
    orient: Qt.QHBoxLayout
    type: int
    value: '9000'
    widget: radio_buttons
  states: {}
- name: notch_freq_v
  id: variable_qtgui_range
  parameters:
    label: Notch Filter
    rangeType: int
    start: '2000'
    step: '1'
    stop: '15000'
    value: '5000'
  states: {}
- name: pilot_val
  id: variable_function_probe
  parameters:
    block_id: epy_block_5
    function_name: get_pilot_status
    poll_rate: '10'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1000e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import math
      from scipy import signal  # <--- THIS FIXES THE "NOT DEFINED" ERROR

      class cquam_decoder(gr.sync_block):
          def __init__(self, sample_rate=120000, notch_freq=9000, notch_q=30.0, mono_mode=False):
              gr.sync_block.__init__(self,
                  name="C-QUAM Field Decoder",
                  in_sig=[np.complex64],
                  out_sig=[np.float32, np.float32]
              )
              self.fs = float(sample_rate)
              self.notch_freq = notch_freq
              self.notch_q = notch_q
              self.mono_mode = mono_mode
              
              # PLL & Correction
              self.zeta = 0.707 
              self.omegaN = 100.0
              self._update_gains()

              # States
              self.phz, self.omega2, self.cos_gamma = 0.0, 0.0, 1.0
              
              # Initialize filter states (zi) to prevent clicks
              self.b, self.a = signal.iirnotch(self.notch_freq, self.notch_q, self.fs)
              self.zi_l = signal.lfilter_zi(self.b, self.a) * 0
              self.zi_r = signal.lfilter_zi(self.b, self.a) * 0
              
              # Monitor States
              self.lock_level = 0.0
              self.pilot_mag = 0.0

          def _update_gains(self):
              T = 1.0 / self.fs
              self.alpha = (2.0 * self.zeta * self.omegaN * T) / (1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2)
              self.beta = ((self.omegaN * T)**2) / (1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2)
              
              ############################################################################################################
              #The code of interest below, I have entered in both of the GUI blocks where the ID field contains notch_freq, 
              #I enabled one and disabled the other to test each, 
              #neither the select or the slider works, 
              #still is stuck on the default setting, I can change the default to 5KHz on the shortwave station, then it works,
              #Same thing if I tune into an AM broadcast station when the default is at 5KHz, theres the whistle,
              #vary or select 9KHz, whistle is still there, close program, fill default with 9KHz, then it works
              #########################################################################################################

          def _update_notch_coeffs(self):
              """Calculates coefficients only when a control changes."""
              self.b, self.a = signal.iirnotch(self.notch_freq, self.notch_q, self.fs) #this matches up exactly so I have not changed it

          # Callbacks for GRC
          #def set_notch_freq(self, notch_freq):          #(self, freq): 
              ##self.notch_freq = freq #this is the previous that has been replaces with the line below
              #self.notch_freq = notch_freq #this is the replacement under suggestion
              #self._update_notch_coeffs()
              
          def set_notch_freq(self, notch_freq):
              print(f"DEBUG: Notch updating to {notch_freq} Hz") # <--- ADD THIS
              #print(notch_freq)
              self.notch_freq = notch_freq
              self._update_notch_coeffs()


          def set_notch_q(self, notch_q):         #(self, q):
              #self.notch_q = q   #this is the previous that has been replaces with the line below
              self.notch_q = notch_q #this is the replacement under suggestion
              self._update_notch_coeffs()
              
              ############################
              #End of the code of interest
              ############################
              
              

          def set_mono_mode(self, mode): self.mono_mode = bool(mode)

          def work(self, input_items, output_items):
              inp, L, R = input_items[0], output_items[0], output_items[1]
              n = len(inp)
              
              # Temporary arrays to hold raw audio before the notch
              raw_l = np.zeros(n, dtype=np.float32)
              raw_r = np.zeros(n, dtype=np.float32)
              
              # Fast local copies
              phz, omega2, cos_gamma = self.phz, self.omega2, self.cos_gamma
              
              # 1. THE DEMODULATION LOOP (Keep your original logic)
              for i in range(n):
                  vco = math.cos(phz) - 1j * math.sin(phz)
                  bb = inp[i] * vco
                  I, Q = bb.real, bb.imag
                  env = math.sqrt(I*I + Q*Q) + 1e-9
                  
                  # PLL
                  det = Q / env 
                  omega2 += self.beta * det
                  phz = (phz + self.alpha * det + omega2) % (2.0 * math.pi)

                  # C-QUAM Logic
                  cos_gamma += 0.005 * ((I / env) - cos_gamma)
                  LpR = (env * cos_gamma) - 1.0
                  LmR = Q / cos_gamma

                  raw_l[i], raw_r[i] = 0.5*(LpR + LmR), 0.5*(LpR - LmR)

              # Update persistent states
              self.phz, self.omega2, self.cos_gamma = phz, omega2, cos_gamma

              # 2. EFFICIENT NOTCH FILTERING (Run once per block, outside the loop)
              L[:], self.zi_l = signal.lfilter(self.b, self.a, raw_l, zi=self.zi_l)
              R[:], self.zi_r = signal.lfilter(self.b, self.a, raw_r, zi=self.zi_r)

              # Mono mode check
              if self.mono_mode:
                  m = 0.5 * (L + R)
                  L[:], R[:] = m, m

              return n
    mono_mode: mono_mode
    notch_freq: notch_freq
    notch_q: '20'
    sample_rate: '120000'
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import math

      class cquam_decoder(gr.sync_block):
          def __init__(self, sample_rate=120000, notch_freq=9000.0, notch_q=30.0):
              gr.sync_block.__init__(self,
                  name="C-QUAM Decoder with IIR Notch",
                  in_sig=[np.complex64],
                  out_sig=[np.float32, np.float32]
              )
              self.fs = float(sample_rate)
              self.notch_freq = notch_freq
              self.notch_q = notch_q
              
              # PLL Constants (Widened loop slightly for faster re-acquisition)
              self.zeta = 0.707 
              self.omegaN = 100.0
              self._update_gains()

              # States
              self.phz = 0.0
              self.omega2 = 0.0
              self.cos_gamma = 1.0
              self.mono_mode = False
              
              # IIR Notch States (Direct Form II)
              self.v1_l, self.v2_l = 0.0, 0.0
              self.v1_r, self.v2_r = 0.0, 0.0
              self._update_notch_coeffs()

              self.message_port_register_in(pmt.intern("mono"))
              self.set_msg_handler(pmt.intern("mono"), self.handle_mono)

          def _update_gains(self):
              # Standard second-order loop gains
              T = 1.0 / self.fs
              self.alpha = (2.0 * self.zeta * self.omegaN * T) / (1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2)
              self.beta = ( (self.omegaN * T)**2 ) / (1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2)

          def _update_notch_coeffs(self):
              # Calculate IIR Notch coefficients
              w0 = 2.0 * math.pi * self.notch_freq / self.fs
              bw = w0 / self.notch_q
              alpha = math.sin(bw) / 2.0
              cos0 = math.cos(w0)
              
              a0 = 1.0 + alpha
              self.b0 = 1.0 / a0
              self.b1 = (-2.0 * cos0) / a0
              self.b2 = 1.0 / a0
              self.a1 = (-2.0 * cos0) / a0
              self.a2 = (1.0 - alpha) / a0

          def handle_mono(self, msg):
              self.mono_mode = bool(pmt.to_long(msg))

          def work(self, input_items, output_items):
              inp, L, R = input_items[0], output_items[0], output_items[1]
              
              # Sync local variables for speed
              phz, omega2, cos_gamma = self.phz, self.omega2, self.cos_gamma
              b0, b1, b2, a1, a2 = self.b0, self.b1, self.b2, self.a1, self.a2
              
              for i in range(len(inp)):
                  # 1. VCO & Mix to Baseband
                  vco = math.cos(phz) - 1j * math.sin(phz)
                  baseband = inp[i] * vco
                  I, Q = baseband.real, baseband.imag
                  
                  # 2. Envelope & Normalization
                  env = math.sqrt(I*I + Q*Q) + 1e-9
                  
                  # 3. PLL Phase Detector (Normalize to prevent lock loss on fades)
                  det = Q / env 
                  
                  # 4. Loop Filter
                  omega2 += self.beta * det
                  phz += self.alpha * det + omega2
                  phz %= (2.0 * math.pi)

                  # 5. C-QUAM Decoding Logic
                  # cos_gamma tracks the average I/env to correct for C-QUAM non-linearity
                  cos_gamma += 0.005 * ((I / env) - cos_gamma)
                  
                  # Matrixing
                  LpR = (env * cos_gamma) - 1.0  # Sum
                  LmR = Q / cos_gamma            # Difference (scaled for centering)

                  l_raw = 0.5 * (LpR + LmR)
                  r_raw = 0.5 * (LpR - LmR)

                  # 6. Apply IIR Notch to L and R channels
                  # Left Channel Filter
                  v_l = l_raw - a1 * self.v1_l - a2 * self.v2_l
                  l_out = b0 * v_l + b1 * self.v1_l + b2 * self.v2_l
                  self.v2_l, self.v1_l = self.v1_l, v_l
                  
                  # Right Channel Filter
                  v_r = r_raw - a1 * self.v1_r - a2 * self.v2_r
                  r_out = b0 * v_r + b1 * self.v1_r + b2 * self.v2_r
                  self.v2_r, self.v1_r = self.v1_r, v_r

                  # 7. Output & Mono Mode
                  if self.mono_mode:
                      mono = 0.5 * (l_out + r_out)
                      L[i] = R[i] = mono
                  else:
                      L[i], R[i] = l_out, r_out

              self.phz, self.omega2, self.cos_gamma = phz, omega2, cos_gamma
              return len(inp)
      """

      """
      import numpy as np
      from gnuradio import gr
      from scipy import signal

      class cquam_anti_warble(gr.sync_block):
          def __init__(self, sample_rate=120000, notch_freq=9000.0, bw=6000.0):
              gr.sync_block.__init__(self, name="Liquid_CQUAM",
                  in_sig=[np.complex64], out_sig=[np.float32, np.float32])
              self.fs = float(sample_rate)
              self.notch_f = notch_freq
              self.bw = bw
              
              # PLL States - Low bandwidth for "liquid" sound
              self.phase_base = 0.0
              self.freq_acc = 0.0
              self.alpha = 0.02  # Lower = smoother, higher = faster lock
              
              # Filter State Management
              self.zi_l = self.zi_r = None
              self._update_filters()

          def _update_filters(self):
              b_n, a_n = signal.iirnotch(self.notch_f, 30.0, fs=self.fs)
              b_l, a_l = signal.butter(4, self.bw, fs=self.fs, btype='low')
              self.b, self.a = signal.convolve(b_n, b_l), signal.convolve(a_n, a_l)
              
              # Vital: Do not reset zi if it already exists to avoid "pops"
              if self.zi_l is None:
                  self.zi_l = signal.lfilter_zi(self.b, self.a) * 0
                  self.zi_r = signal.lfilter_zi(self.b, self.a) * 0

          def set_notch_freq(self, f): self.notch_f = f; self._update_filters()
          def set_bw(self, b): self.bw = b; self._update_filters()

          def work(self, input_items, output_items):
              in0 = input_items
              n = len(in0)
              
              # 1. ANALYSE: Find phase error once per block
              vco_last = np.exp(-1j * self.phase_base)
              error = np.angle(np.mean(in0 * vco_last) + 1e-9)
              
              # 2. SMOOTH: Linear Phase Interpolation (The Anti-Warble)
              # We calculate a frequency that will correct the error by the END of the block
              target_freq = error / n 
              self.freq_acc = 0.95 * self.freq_acc + 0.05 * target_freq # Flywheel damping
              
              # Create a smooth linear ramp from 0 to n*freq_acc
              phase_ramp = self.phase_base + np.arange(n) * self.freq_acc
              vco = np.exp(-1j * phase_ramp)
              
              # 3. DEMOD & MATRIX
              bb = in0 * vco
              env = np.abs(in0)
              LpR = env - np.mean(env) # Sum
              LmR = bb.imag           # Difference
              
              # 4. FILTER
              output_items[:], self.zi_l = signal.lfilter(self.b, self.a, 0.5*(LpR + LmR), zi=self.zi_l)
              output_items[:], self.zi_r = signal.lfilter(self.b, self.a, 0.5*(LpR - LmR), zi=self.zi_r)
              
              # Update for next block
              self.phase_base = (phase_ramp[-1] + self.freq_acc) % (2*np.pi)
              
              return n
      """

      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import math
      from scipy import signal

      class cquam_decoder(gr.sync_block):
          def __init__(self, sample_rate=120000, notch_freq=9000, notch_q=30.0, mono_mode=False):
              gr.sync_block.__init__(self,
                  name="C-QUAM Field Decoder",
                  in_sig=[np.complex64],
                  out_sig=[np.float32, np.float32]
              )
              self.fs = float(sample_rate)
              self.notch_freq = notch_freq
              self.notch_q = notch_q
              self.mono_mode = mono_mode
              
              #The update starts here
              
              # Initialize filter states (zi) to prevent clicks
              self.b, self.a = signal.iirnotch(self.notch_freq, self.notch_q, self.fs)
              self.zi_l = signal.lfilter_zi(self.b, self.a) * 0
              self.zi_r = signal.lfilter_zi(self.b, self.a) * 0
              
              # PLL & Correction
              self.zeta = 0.707 
              self.omegaN = 100.0
              self._update_gains()

              # States
              self.phz, self.omega2, self.cos_gamma = 0.0, 0.0, 1.0
              self.v1_l, self.v2_l = 0.0, 0.0
              self.v1_r, self.v2_r = 0.0, 0.0
              
              # Monitor States (For LEDs)
              self.lock_level = 0.0
              self.pilot_mag = 0.0
              
              self._update_notch_coeffs()

          def _update_gains(self):
              T = 1.0 / self.fs
              self.alpha = (2.0 * self.zeta * self.omegaN * T) / (1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2)
              self.beta = ((self.omegaN * T)**2) / (1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2)
              
              

          #def _update_notch_coeffs(self):
              #w0 = 2.0 * math.pi * self.notch_freq / self.fs
              #bw = w0 / self.notch_q
              #alpha = math.sin(bw) / 2.0
              #cos0, a0 = math.cos(w0), 1.0 + alpha
              #self.b0, self.b1, self.b2 = 1.0/a0, (-2.0*cos0)/a0, 1.0/a0
              #self.a1, self.a2 = (-2.0*cos0)/a0, (1.0-alpha)/a0
              
              #the updated Code here that replaces the one above
          def _update_notch_coeffs(self):
              #Calculates coefficients ONLY when a control changes.
              self.b, self.a = signal.iirnotch(self.notch_freq, self.notch_q, self.fs)
              # Note: We don't reset zi here to keep the audio smooth during the slide

          # These callbacks fix the 'not responding' issue
          def set_notch_freq(self, notch_freq):
              if self.notch_freq != notch_freq:
                  self.notch_freq = notch_freq
                  self._update_notch_coeffs()

          def set_notch_q(self, notch_q):
              if self.notch_q != notch_q:
                  self.notch_q = notch_q
                  self._update_notch_coeffs()

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out_l = output_items[0]
              out_r = output_items[1]
              # the updated code stops here

          # Command Interfaces for GRC
          def set_mono_mode(self, mode): self.mono_mode = bool(mode)
          def set_notch_freq(self, freq): self.notch_freq = freq; self._update_notch_coeffs()
          def get_lock_status(self): return self.lock_level
          def get_pilot_status(self): return 1.0 if self.pilot_mag > 0.015 else 0.0

          def work(self, input_items, output_items):
              inp, L, R = input_items[0], output_items[0], output_items[1]
              p_step = 2.0 * math.pi * 25.0 / self.fs
              
              # Fast local copies
              phz, omega2, cos_gamma = self.phz, self.omega2, self.cos_gamma
              
              for i in range(len(inp)):
                  vco = math.cos(phz) - 1j * math.sin(phz)
                  bb = inp[i] * vco
                  I, Q = bb.real, bb.imag
                  env = math.sqrt(I*I + Q*Q) + 1e-9
                  
                  # PLL
                  det = Q / env 
                  omega2 += self.beta * det
                  phz = (phz + self.alpha * det + omega2) % (2.0 * math.pi)

                  # C-QUAM Logic
                  cos_gamma += 0.005 * ((I / env) - cos_gamma)
                  LpR = (env * cos_gamma) - 1.0
                  LmR = Q / cos_gamma

                  # Monitor Logic (Lock & 25Hz Pilot)
                  self.lock_level += 0.001 * (max(0, I/env) - self.lock_level)
                  self.pilot_mag += 0.0002 * (abs(LmR * (math.sin(phz*0.0002))) - self.pilot_mag) # simplified corr

                  l_raw, r_raw = 0.5*(LpR + LmR), 0.5*(LpR - LmR)
                  
                  
                  #This is the old Notch filter loop

                  ## Notch Filtering
                  #v_l = l_raw - self.a1*self.v1_l - self.a2*self.v2_l
                  #l_out = self.b0*v_l + self.b1*self.v1_l + self.b2*self.v2_l
                  #self.v1_l, self.v2_l = v_l, self.v1_l
                  
                  #v_r = r_raw - self.a1*self.v1_r - self.a2*self.v2_r
                  #r_out = self.b0*v_r + self.b1*self.v1_r + self.b2*self.v2_r
                  #self.v1_r, self.v2_r = v_r, self.v1_r
                  
                  # This is the new Notch filter loop replacement
                  # Replace your manual notch loop with these two lines:
                  out_l[:], self.zi_l = signal.lfilter(self.b, self.a, l_raw, zi=self.zi_l) # l_raw was replaced with raw_l
                  out_r[:], self.zi_r = signal.lfilter(self.b, self.a, r_raw, zi=self.zi_r) # r_raw was replaced with r_raw
                  
                  return len(in0)

                  if self.mono_mode:
                      m = 0.5 * (l_out + r_out)
                      L[i] = R[i] = m
                  else:
                      L[i], R[i] = l_out, r_out

              self.phz, self.omega2, self.cos_gamma = phz, omega2, cos_gamma
              return len(inp)

      """

      import numpy as np
      from gnuradio import gr
      import math
      from scipy import signal

      class cquam_decoder(gr.sync_block):
          def __init__(self, sample_rate=120000, notch_freq=9000, notch_q=30.0, mono_mode=False):
              gr.sync_block.__init__(self,
                  name="C-QUAM Field Decoder",
                  in_sig=[np.complex64],
                  out_sig=[np.float32, np.float32]
              )
              self.fs = float(sample_rate)
              self.notch_freq = notch_freq
              self.notch_q = notch_q
              self.mono_mode = mono_mode
              
              # PLL & States
              self.zeta, self.omegaN = 0.707, 100.0
              self._update_gains()
              self.phz, self.omega2, self.cos_gamma = 0.0, 0.0, 1.0
              self.lock_level, self.pilot_mag = 0.0, 0.0
              
              # Initialize filter coefficients and states
              self._update_notch_coeffs()
              self.zi_l = signal.lfilter_zi(self.b, self.a) * 0
              self.zi_r = signal.lfilter_zi(self.b, self.a) * 0

          def _update_gains(self):
              T = 1.0 / self.fs
              denom = 1.0 + 2.0 * self.zeta * self.omegaN * T + (self.omegaN * T)**2
              self.alpha = (2.0 * self.zeta * self.omegaN * T) / denom
              self.beta = ((self.omegaN * T)**2) / denom

          def _update_notch_coeffs(self):
              # Optimized Scipy notch
              self.b, self.a = signal.iirnotch(self.notch_freq, self.notch_q, self.fs)

          def set_notch_freq(self, notch_freq):
              if self.notch_freq != notch_freq:
                  self.notch_freq = notch_freq
                  self._update_notch_coeffs()

          def set_notch_q(self, notch_q):
              if self.notch_q != notch_q:
                  self.notch_q = notch_q
                  self._update_notch_coeffs()

          def set_mono_mode(self, mode): self.mono_mode = bool(mode)
          def get_lock_status(self): return self.lock_level
          def get_pilot_status(self): return 1.0 if self.pilot_mag > 0.015 else 0.0

          def work(self, input_items, output_items):
              inp = input_items[0]
              L_out = output_items[0]
              R_out = output_items[1]
              n = len(inp)

              # Buffers to hold raw demodulated audio for vector filtering
              raw_l = np.zeros(n, dtype=np.float32)
              raw_r = np.zeros(n, dtype=np.float32)
              
              phz, omega2, cos_gamma = self.phz, self.omega2, self.cos_gamma
              
              # 1. PER-SAMPLE DEMODULATION & MONITORING
              for i in range(n):
                  vco = math.cos(phz) - 1j * math.sin(phz)
                  bb = inp[i] * vco
                  I, Q = bb.real, bb.imag
                  env = math.sqrt(I*I + Q*Q) + 1e-9
                  
                  # PLL
                  det = Q / env 
                  omega2 += self.beta * det
                  phz = (phz + self.alpha * det + omega2) % (2.0 * math.pi)

                  # C-QUAM Logic
                  cos_gamma += 0.005 * ((I / env) - cos_gamma)
                  LpR = (env * cos_gamma) - 1.0
                  LmR = Q / cos_gamma

                  # Monitor Logic (Lock & 25Hz Pilot)
                  self.lock_level += 0.001 * (max(0, I/env) - self.lock_level)
                  # Pilot check (using LmR for stereo difference)
                  self.pilot_mag += 0.0002 * (abs(LmR * (math.sin(phz*0.0002))) - self.pilot_mag) #this has beeh taken out to match suggested code - self.pilot_mag)

                  raw_l[i], raw_r[i] = 0.5*(LpR + LmR), 0.5*(LpR - LmR)

              self.phz, self.omega2, self.cos_gamma = phz, omega2, cos_gamma

              # 2. VECTORIZED NOTCH FILTERING (OUTSIDE THE LOOP)
              # This is where the speed comes from!
              L_out[:], self.zi_l = signal.lfilter(self.b, self.a, raw_l, zi=self.zi_l)
              R_out[:], self.zi_r = signal.lfilter(self.b, self.a, raw_r, zi=self.zi_r)

              if self.mono_mode:
                  m = 0.5 * (L_out + R_out)
                  L_out[:], R_out[:] = m, m

              return n
    mono_mode: mono_mode
    notch_freq: notch_freq
    notch_q: '1'
    sample_rate: '120000'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-100e3'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {}
- name: lock_val
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    label: Carrier Lock
    state: True if Stereo_Lock > 0.7 else False
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_bw
    gain: '3'
    interp: '1'
    maxoutbuf: '16'
    minoutbuf: '4'
    samp_rate: '120000'
    type: interp_fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: pilot_led
  id: qtgui_ledindicator
  parameters:
    cellalignment: '3'
    label: Stereo Pilot
    offColor: black
    onColor: blue
    state: True if pilot_val > 0.5 else False
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000'
    interp: '120'
    maxoutbuf: '16'
    minoutbuf: '4'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '120'
    interp: '48'
    maxoutbuf: '16'
    minoutbuf: '4'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '120'
    interp: '48'
    maxoutbuf: '16'
    minoutbuf: '4'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0,direct_samp=2
    bb_gain0: '1'
    bw0: '15000'
    freq0: freq+100000
    gain0: '0'
    gain_mode0: 'True'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-4'
    reference: '0.2'
  states: {}

connections:
- [epy_block_0, '0', rational_resampler_xxx_0_0_0_0_0, '0']
- [epy_block_0, '1', rational_resampler_xxx_0_0_0_0, '0']
- [epy_block_5, '0', rational_resampler_xxx_0_0_0_0, '0']
- [epy_block_5, '1', rational_resampler_xxx_0_0_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']
- [low_pass_filter_0, '0', epy_block_5, '0']
- [rational_resampler_xxx_0_0_0, '0', satellites_rms_agc_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0_0_0_0, '0', audio_sink_0, '1']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [satellites_rms_agc_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
